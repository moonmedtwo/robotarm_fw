# Keil uVision project example.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IROM(0x08000000,0x00100000) IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: example +hex
  c flags: Optim=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F40_41xxx, HSE_VALUE=8000000
  c include: .\Source;.\Source\app\inc;.\Source\stm32\inc;.\Source\stm32\STM32F4xx_StdPeriph_Driver\inc
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group user
    ./: startup_stm32f40_41xxx.s
    ./Source/: main.c
    ./Source/app/src/: configuration.c controller.c eeprom.c invKin.c matrix.c user_timing.c user_uart.c util.c
  group stm32_system
    ./Source/stm32/src/: stm32f4xx_it.c system_stm32f4xx.c
  group stm32_stdperiph_drivers
    ./Source/stm32/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_gpio.c stm32f4xx_iwdg.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_wwdg.c stm32f4xx_usart.c
software components: CMSIS:CORE 4.3.0
